# Keil uVision project benchmark.uvprojx, settings and files
target Benchmark-speed (5060960::V5.06 update 7 (build 960)::.\ARM_Compiler_5.06u7)
  device: STM32F407IGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.8.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: armcc-speed +hex
  c flags: Optim=3 oTime=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F407xx
  c misc: --fpmode=std --apcs=/hardfp
  c include: ..\..\Drivers;..\..\Drivers\CMSIS\Include;..\..\Drivers\CMSIS\Device\ST\STM32F4xx\Include;..\..\User;..\..\bench;..\..\bench\coremark;..\..\third_party\coremark
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: ..\..\startup\flash.sct
  group Startup
    ../../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f407xx.s
  group Drivers/SYSTEM
    ../../Drivers/SYSTEM/sys/: sys.c
  group Benchmark
    ../../bench/: main.c kernels.c algorithms.c peripherals.c integer_kernels.c integer_workloads.c
    ../../bench/coremark/: core_portme.c
    ../../third_party/coremark/: core_main.c core_list_join.c core_matrix.c core_state.c core_util.c
target Benchmark-size (5060960::V5.06 update 7 (build 960)::.\ARM_Compiler_5.06u7)
  device: STM32F407IGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.8.0
  cpu: as above
  output: armcc-size +hex
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F407xx,BENCH_SIZE=1
  c misc: --fpmode=std --apcs=/hardfp
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: ..\..\startup\flash.sct
