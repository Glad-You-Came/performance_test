LR_FLASH 0x08000000 0x00100000 {
  ER_FLASH 0x08000000 0x00100000 {
    *.o (RESET, +First)
    *(InRoot$$Sections)
    .ANY (+RO)
  }
  RW_SRAM1 0x20000000 0x0001c000 {
    .ANY (+RW +ZI)
  }
}
